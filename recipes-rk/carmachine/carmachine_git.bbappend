SRC_URI = " \
	git://github.com/rockchip-linux/carmachine.git;branch=master \
"
SRCREV = "0ebdbf0256a133801112942d6dcfd844a0aba970"

