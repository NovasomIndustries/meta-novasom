SRC_URI = "https://github.com/rockchip-linux/libmali/raw/master/lib/${MALI_TUNE}/${MALI_NAME}"
SRC_URI[md5sum] = "b30b99d8ae6516a0957860c66735efb8"
