FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-Added-base-DTS-for-Novasom-M7.patch \
	file://defconfig \
"

